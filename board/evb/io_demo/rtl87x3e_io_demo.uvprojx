# Keil uVision project rtl87x3e_io_demo.uvprojx, settings and files
target IO_DEMO_4M (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: io_demo +hex
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M "0" rtl87x3e
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_4M rtl87x3e
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PRE_UPPERSTACK=1 NOT_SUPPORT_UPPERSTACK
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\rtl87x3e\platform;..\template;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\rtl87x3e\io;..\io_demo;..\..\..\src\sample\io_demo\ir\protocol;..\..\..\src\mcu\rtl87x3;..\..\..\inc\rtl87x3e\hal\;..\..\..\bin\rtl87x3e\upperstack_stamp;.\inc\rtl87x3e;..\..\..\bin\rtl87x3e\flash_map_config
  asm misc: --cpreproc
  asm include: .\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_io_demo.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../inc/rtl87x3e/platform/: rom_uuid.h
  group lib
    ../../../bin/rtl87x3e/: ROM.lib hal_utils.lib upperstack_2M.lib
  group cmsis
    ../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group app
    ../../../src/sample/io_demo/: main.c
  group adc
    ../../../src/sample/io_demo/adc/one-shot/: adc_demo.c
  group gdma
    ../../../src/sample/io_demo/gdma/adc_dma/: adc_gdma_demo.c
    ../../../src/sample/io_demo/gdma/i2c_dma/MasterRx+SlaveTx/: i2c_dma_demo.c
    ../../../src/sample/io_demo/gdma/memtomem/: gdma_demo.c
    ../../../src/sample/io_demo/gdma/multiblock/: dma_multiblock_demo.c
    ../../../src/sample/io_demo/gdma/multiblock_tim_gpio/: dma_tim_demo.c
    ../../../src/sample/io_demo/gdma/scatter_gather/: dma_scrgar_demo.c
    ../../../src/sample/io_demo/gdma/uart_idle_rx/: uart_rx_dma.c
    ../../../src/sample/io_demo/gdma/uart_tx/: uart_tx_gdma.c
  group gpio
    ../../../src/sample/io_demo/gpio/input/: gpio_input_demo.c
    ../../../src/sample/io_demo/gpio/interrupt/: gpio_int_demo.c
    ../../../src/sample/io_demo/gpio/key/level_tim/: gpio_key.c
  group i2c
    ../../../src/sample/io_demo/i2c/interrupt/: i2c_demo.c
    ../../../src/sample/io_demo/i2c/master_write/: i2c_mw_demo.c
    ../../../src/sample/io_demo/i2c/polling/: i2c_polling_demo.c
    ../../../src/sample/io_demo/i2c/slave/: i2c_slave_demo.c
  group ir
    ../../../src/sample/io_demo/ir/protocol/: ir_nec_protocol.c
    ../../../src/sample/io_demo/ir/receive/: ir_receive_demo.c
  group keyscan
    ../../../src/sample/io_demo/keyscan/active/: keyscan_demo.c
    ../../../src/sample/io_demo/keyscan/dlps/: keyscan_demo_dlps.c
  group led
    ../../../src/sample/io_demo/led/: led_demo.c
  group lpc
    ../../../src/sample/io_demo/lpc/comparator/: lpc_comparator_demo.c
    ../../../src/sample/io_demo/lpc/voltage_detection/: lpc_rtc_vol_demo.c lpc_peri_vol_demo.c
  group qdec
    ../../../src/sample/io_demo/qdec/: qdec_demo.c
  group rtc
    ../../../src/sample/io_demo/rtc/comparator/: rtc_demo.c
    ../../../src/sample/io_demo/rtc/overflow/: rtc_overflow_demo.c
    ../../../src/sample/io_demo/rtc/tick/: rtc_tick_demo.c
  group sdio
    ../../../src/sample/io_demo/sdio/sdcard/: sdcard.c
  group spi
    ../../../src/sample/io_demo/spi/dynamic_switch_cs/: spi_switchcs_demo.c
    ../../../src/sample/io_demo/spi/interrupt/: spi_master_demo.c
    ../../../src/sample/io_demo/spi/polling/: spi_demo.c
    ../../../src/sample/io_demo/spi/slave/: spi_slave_demo.c
  group spi3w
    ../../../src/sample/io_demo/spi3w/polling/: spi3wire_demo.c
  group tim
    ../../../src/sample/io_demo/tim/pwm/: pwm_demo.c
    ../../../src/sample/io_demo/tim/interrupt/: tim_demo.c
  group uart
    ../../../src/sample/io_demo/uart/dlps/: dlps_uart_demo.c
    ../../../src/sample/io_demo/uart/hw_flow_control/: uart_fc_demo.c
    ../../../src/sample/io_demo/uart/interrupt/: uart_demo.c
  group ctc
    ../../../src/sample/io_demo/captouch/: cap_touch_demo.c
