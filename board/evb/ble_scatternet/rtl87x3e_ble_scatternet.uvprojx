# Keil uVision project rtl87x3e_ble_scatternet.uvprojx, settings and files
target ble_scatternet_4M_bank0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ble_scatternet
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe" "#L" @L bank0 flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0 --preinclude board.h
  c include: ..\ble_scatternet;..\..\..\src\sample\ble_scatternet;..\..\..\src\mcu\module\data_uart_cmd;..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\io;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\src\mcu\rtl87x3;..\..\..\inc\rtl87x3e\hal;..\..\..\bin\rtl87x3e\upperstack_stamp;.\inc\rtl87x3e;..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\inc\rtl87x3e\bluetooth\gap
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_ble_scatternet_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../inc/rtl87x3e/platform/: rom_uuid.h
    ./: config.h
  group lib
    ../../../bin/rtl87x3e/: gap_utils.lib ROM.lib hal_utils.lib upperstack_2M.lib upperstack_4M.lib
  group cmsis
    ../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group profile
    ../../../src/ble/profile/client/: bas_client.c gaps_client.c simple_ble_client.c
    ../../../src/ble/profile/server/: simple_ble_service.c bas.c
  group app
    ../../../src/sample/ble_scatternet/: app_task.c link_mgr.c main.c scatternet_app.c user_cmd.c
    ../../../src/mcu/module/data_uart_cmd/: data_uart.c user_cmd_parse.c
