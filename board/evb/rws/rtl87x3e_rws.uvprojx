# Keil uVision project rtl87x3e_rws.uvprojx, settings and files
target rws_2M_T135_dual_bank0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rws
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 2M "0" rtl87x3e harman
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_2M_dualbank\T135 rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: IC_TYPE_BB2_CCUT = 1 HARMAN_T135_SUPPORT = 1
  c misc: --gnu --bss_threshold=0 --diag_suppress=177 --preinclude app_flags.h --preinclude app_flags_customer.h --feedback .\target\general\fout.txt
  c include: .\inc\rtl87x3e;..\rws;..\..\..\inc\app;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\io;..\..\..\inc\stack;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\rtl87x3e\platform\console;..\..\..\inc\framework;..\..\..\inc\framework\sys;..\..\..\inc\framework\audio;..\..\..\inc\framework\mmi;..\..\..\inc\framework\bt;..\..\..\inc\framework\remote;..\..\..\inc\framework\console;..\..\..\inc\rtl87x3e\hal;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\leaudio;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\service;..\..\..\inc\service\gfps;..\..\..\inc\service\bisto;..\..\..\inc\service\xiaoai;..\..\..\inc\service\xiaowei;..\..\..\inc\service\ama;..\..\..\inc\service\teams;..\..\..\inc\service\teams\asp_device;..\..\..\inc\service\teams\hid;..\..\..\src\mcu\module\led;..\..\..\inc\rtl87x3e\hal\power;..\..\..\src\mcu\legacy\spp_ota;..\..\..\src\mcu\rtl876x;..\..\..\src\mcu\module\vector;..\..\..\src\mcu\module\stream;..\..\..\src\ble\adv_mgr;..\..\..\src\ble\ble_conn_update;..\..\..\src\ble\gatt_client;..\..\..\src\debug;..\..\..\src\sample\rws;..\..\..\src\sample\rws\local_playback;..\..\..\src\sample\rws\local_playback\sd_emmc;..\..\..\src\sample\rws\bqb;..\..\..\src\sample\rws\console;..\..\..\src\sample\rws\cli;..\..\..\src\sample\rws\bud;..\..\..\src\sample\rws\mp;..\..\..\src\sample\rws\app;..\..\..\src\sample\rws\engage;..\..\..\src\sample\rws\gfps;..\..\..\src\sample\rws\xiaoai;..\..\..\src\sample\rws\bisto;..\..\..\src\sample\rws\bisto;..\..\..\src\sample\rws\ama;..\..\..\src\sample\rws\eq;..\..\..\src\sample\rws\dongle;..\..\..\src\sample\rws\teams;..\..\..\src\sample\rws\teams\asp_device;..\..\..\src\sample\rws\teams\hid;..\..\..\src\sample\rws\teams;..\..\..\src\sample\rws\xiaowei;..\..\..\src\sample\rws\isoaudio;..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_app;..\..\..\src\sample\rws\tuya\tuya_enc\mbedtls;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_port;..\..\..\src\sample\rws\tuya\tuya_ble_sdk;..\..\..\src\sample\rws\tuya\tuya_enc;..\..\..\inc\ble_mgr;..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\src\sample\rws\harman;..\..\..\..\hal\inc\bb2_ccut;..\..\..\src\sample\rws\ext_charger
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_rws_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off  --feedback .\target\general\fout.txt
  group include
    ./: config.h
    ../../../src/sample/rws/: app_flags.h app_flags_customer.h
    ../../../inc/rtl87x3e/platform/: rom_uuid.h
  group lib
    ../../../bin/rtl87x3e/: gap_utils.lib ROM.lib framework.lib hal_utils.lib engage.lib upperstack_2M.lib upperstack_4M.lib ble_mgr.lib leaudio.lib multitopology_ctrl.lib gfps.lib
  group cmsis
    ../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group io
    ../../../src/sample/rws/: app_sensor_iqs773_873.c app_vendor_iqs773_873.c
  group module
    ../../../src/mcu/module/led/: led_module.c
    ../../../src/mcu/module/vector/: vector.c
    ../../../src/sample/rws/: image_header.c
  group console
    ../../../src/sample/rws/console/: console_uart.c
  group cli
    ../../../src/sample/rws/cli/: cli_cfg_cmd.c cli_cfg_main.c cli_power_cmd.c cli_lpm_cmd.c
  group bqb
    ../../../src/sample/rws/bqb/: bqb_main.c bqb_cmd.c
  group ble
    ../../../src/ble/profile/client/: ancs_client.c ams_client.c
    ../../../src/ble/profile/server/: transmit_service.c ota_service.c bas.c dis.c
    ../../../src/ble/gatt_client/: bt_gatt_client.c bt_gattc_storage.c gattc_tbl_storage.c bt_ext_ftl.c
  group app
    ../../../src/sample/rws/: app_main.c app_util.c app_cfg.c app_io_msg.c app_led.c app_gpio.c app_key_gpio.c app_key_process.c app_charger.c app_transfer.c app_report.c app_gap.c app_ble_gap.c app_ble_device.c app_ble_client.c app_ble_service.c app_ble_common_adv.c app_sdp.c app_hfp.c app_avrcp.c app_a2dp.c app_pbap.c app_iap.c app_roleswap.c app_relay.c app_device.c app_mmi.c app_dlps.c app_link_util.c app_linkback.c app_multilink.c app_bt_policy.c app_audio_policy.c app_gpio_on_off.c app_rdtp.c app_anc.c app_eq.c app_nfc.c app_sensor.c app_ota.c app_bt_policy_api.c app_in_out_box.c app_iap_rtk.c app_ble_tts.c app_buzeer.c app_bond.c app_third_party_srv.c app_bt_sniffing.c app_adp.c app_io_output.c app_console_msg.c app_spp.c app_cmd.c app_sensor_px318j.c app_auto_power_off.c app_line_in.c app_airplane.c app_dsp_cfg.c app_adc.c app_ble_swift_pair.c app_audio_route.c app_sniff_mode.c app_iphone_abs_vol_handle.c app_ble_bond.c app_sensor_jsa.c rtk_charger.c app_one_wire_uart.c app_bud_loc.c app_single_multilink_customer.c app_rtk_fast_pair_adv.c app_ble_rand_addr_mgr.c app_roleswap_control.c app_amp.c app_sass_policy.c app_test.c
    ../../../src/sample/rws/eq/: eq_utils.c
    ../../../src/sample/rws/ext_charger/: app_ext_charger.c
  group mp
    ../../../src/sample/rws/mp/: cli_mp_main.c mp_cmd_main.c mp_test.c mp_test_vendor.c single_tone.c
  group gfps
    ../../../src/sample/rws/gfps/: app_gfps.c app_gfps_account_key.c app_gfps_device.c app_gfps_personalized_name.c app_gfps_rfc.c app_ecc.c app_gfps_battery.c app_gfps_finder.c app_gfps_finder_adv.c app_gfps_finder_test_internal.c app_dult.c app_dult_device.c app_dult_svc.c app_gfps_timer.c
  group harman
    ../../../src/sample/rws/harman/: app_harman_ble.c app_harman_parser.c app_harman_report.c app_harman_vendor_cmd.c app_harman_ble_ota.c app_harman_eq.c app_harman_license.c app_harman_adc.c app_harman_usb_connector_protect.c app_harman_behaviors.c app_harman_ntc_const.c
target rws_2M_T135_dual_bank1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: rws
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 2M "1" rtl87x3e harman
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1  flash_2M_dualbank\T135 rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: IC_TYPE_BB2_CCUT = 1 HARMAN_T135_SUPPORT = 1
  c misc: --gnu --bss_threshold=0 --diag_suppress=177 --preinclude app_flags.h --preinclude app_flags_customer.h  --feedback .\target\general\fout.txt
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_rws_bank1.sct
  link misc: --diag_suppress=L6314 --datacompressor off
target rws_2M_T235_dual_bank0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: rws
  BeforeMake: as above
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_2M_dualbank\T235 rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: IC_TYPE_BB2_CCUT = 1 HARMAN_T235_SUPPORT = 1
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_rws_bank0.sct
  link misc: as above
target rws_2M_T235_dual_bank1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: rws
  BeforeMake: as above
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1  flash_2M_dualbank\T235 rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: IC_TYPE_BB2_CCUT = 1 HARMAN_T235_SUPPORT = 1
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_rws_bank1.sct
  link misc: as above
target rws_2M_Run3_dual_bank0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: rws
  BeforeMake: as above
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_2M_dualbank\Run3 rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: IC_TYPE_BB2_CCUT = 1 HARMAN_RUN3_SUPPORT = 1
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_rws_bank0.sct
  link misc: as above
target rws_2M_Run3_dual_bank1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: rws
  BeforeMake: as above
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1  flash_2M_dualbank\Run3 rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: IC_TYPE_BB2_CCUT = 1 HARMAN_RUN3_SUPPORT = 1
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rtl87x3e_rws_bank1.sct
  link misc: as above
